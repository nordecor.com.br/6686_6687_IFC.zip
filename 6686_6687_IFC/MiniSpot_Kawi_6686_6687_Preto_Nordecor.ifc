Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-02-07T16:05:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 07 16:05:26 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\5fc2c65a-b95e-4bc9-bc48-8ae5ccbf9960\a7d43e3b-8fe9-410b-96c4-6c0fcc71b2f2\ifc * Database version: 5507 * Database creation date: Fri Feb 07 16:05:26 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Feb 07 16:05:26 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 07 16:05:26 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_331100
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6687 - Preto, MiniSpot_Kawi_6686_6687_Nordecor_IFC:6687 - Preto:331100
In: Nível 1
Type - Material: Metal - Alumínio extrudado - Preto, Plástico - Acrílico, LED
Type - Cotas - Altura da luminária: 52 mm; Comprimento 01: 0 mm; Comprimento 02: 0 mm; Comprimento da luminária: 72 mm; Comprimento do nicho: 68 mm; Inclinação 01: 0 deg; Inclinação 02: 0 deg; Largura da luminária: 40 mm; Largura do nicho: 35 mm; Rotação horizontal 01: 0 deg; Rotaçao horizontal 02: 0 deg
Type - Dados - Data da atualização: 04/02/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: contato@nordecor.com.br; Descrição: Spot duplo de embutir com borda, com acabamento branco LED 2x2W, 3000K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 anos; Grau de proteção: IP20; Localizção: Camboriú-SC / Brasil; Modelo: 6687; Nome do tipo: 6687 - Preto; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6687.png; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/mini-spot-led-retratil-de-embutir-kawi-duplo-22w-3-000k-irc90/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Fotométricos - Fluxo luminoso: 360 lm; Grau de abertura: 30 deg; IRC (RA): >90; Potência: 2 W; Temperatura de cor: 3000 K
Type - Materiais e acabamentos - Luminária: Metal - Alumínio extrudado - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Comp. 01: 0 mm; Comp. 02: 0 mm; Comp. retrátil 01: 30 mm; Comp. retrátil 02: 30 mm; Comprimento retrátil 01: 30 mm; Comprimento retrátil 02: 30 mm; Incl. 01: 0 deg; Incl. 02: 0 deg; Nome da família: MiniSpot_Kawi_6686_6687_Nordecor_IFC; Preto: yes; Regulagem 01: no; Regulagem 02: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Fonte luminosa: yes
Cotas - Área: 0.0279024 m2; Volume: 0.0000441382 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: MiniSpot_Kawi_6686_6687_Nordecor_IFC: 6687 - Preto; Família e tipo: MiniSpot_Kawi_6686_6687_Nordecor_IFC: 6687 - Preto; ID de tipo: MiniSpot_Kawi_6686_6687_Nordecor_IFC: 6687 - Preto; Tipo: MiniSpot_Kawi_6686_6687_Nordecor_IFC: 6687 - Preto
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
